PACKAGECONFIG:append = " rdoc"
