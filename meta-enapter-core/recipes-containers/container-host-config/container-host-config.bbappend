FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://storage.conf \
    file://registries.conf \
"
